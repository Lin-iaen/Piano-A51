; ╔══════════════════════════════════════════════════════════════════════╗
; ║  第1部分：文件名片                                                     ║
; ╠══════════════════════════════════════════════════════════════════════╣
; ║  文件名: Bsp_DigiTube.asm                                              ║
; ║  层级:   Bsp (板级支持层)                                               ║
; ║  功能:   将音符编号(0~21)翻译成数字，写入数码管驱动层的显示缓冲。        ║
; ║         提供统一的"显示数字"接口——和 Led_ShowSpectrum 一样，             ║
; ║         ACC 传入音符编号，0=灭，1~21=显示对应的数字。                    ║
; ║                                                                        ║
; ║  白话:   LED灯靠灯光图案表示音高（左边亮=低音, 中间=中音, 全亮=高音），   ║
; ║          数码管更直观，直接把音符编号（1,2,3...21）用数字显示出来。       ║
; ║          这个文件就是把"音符编号"翻译成数码管要显示的"数字"。              ║
; ║          类比 Led_ShowSpectrum：都是 ACC 传入音符编号，                  ║
; ║          一个输出到P1(LED)，一个输出到数码管缓冲(Drv_DigiTube)。          ║
; ║                                                                        ║
; ║  调用者: Main.asm 的 Dispatch_Event（单音/静音事件触发）                 ║
; ║         MusicPlayer.asm（播放每个音符时触发）                            ║
; ║  依赖:   Drv_DigiTube.asm (DigiTube_SetNum, DigiTube_Clear)             ║
; ╚══════════════════════════════════════════════════════════════════════╝
;
; ╔══════════════════════════════════════════════════════════════════════╗
; ║  第2部分：汇编指令速查表（本文件出现的所有指令）                        ║
; ╠══════════════════════════════════════════════════════════════════════╣
; ║  LCALL 标签     │ 长调用子函数。这里调用Drv层的 DigiTube_SetNum/Clear   ║
; ║  JZ    标签     │ A=0 则跳转                                            ║
; ║  ------ 以下指令见此前文件，此处简记 ------                              ║
; ║  PUSH / POP / RET                                                     ║
; ╚══════════════════════════════════════════════════════════════════════╝
;
; ╔══════════════════════════════════════════════════════════════════════╗
; ║  第3部分：特殊功能寄存器速查表                                          ║
; ╠══════════════════════════════════════════════════════════════════════╣
; ║  本文件不直接操作SFR。（通过调用Drv_DigiTube间接操作硬件）               ║
; ╚══════════════════════════════════════════════════════════════════════╝

NAME    BSP_DIGITUBE

PUBLIC  DigiTube_ShowNumber
PUBLIC  DigiTube_Off

EXTRN   CODE (DigiTube_SetNum)
EXTRN   CODE (DigiTube_Clear)

BSP_DIGITUBE_CODE SEGMENT CODE
RSEG    BSP_DIGITUBE_CODE

; ========================================================
; DigiTube_ShowNumber — 在数码管上显示音符编号
; 入口: ACC = 音符编号 (0~21)
;       0 = 熄灭数码管（静音）
;       1~21 = 显示该数字（1~21）
; 破坏: ACC (内部已保护)
; ========================================================
DigiTube_ShowNumber:
    PUSH    ACC

    JZ      ShowNumber_Off     ; A=0 → 熄灭

    ; 范围保护：>21 的非法值忽略
    CLR     C
    SUBB    A, #22             ; A = A - 22
    JNC     ShowNumber_Exit    ; CY=0 → A>=22 → 非法，不显示

    ; 合法值 1~21，恢复ACC并显示
    POP     ACC
    PUSH    ACC

    PUSH    82H
    PUSH    83H

    LCALL   DigiTube_SetNum    ; 写入数码管缓冲

    POP 83H
    POP 82H

    SJMP    ShowNumber_Exit

ShowNumber_Off:
    LCALL   DigiTube_Clear     ; 清空所有位

ShowNumber_Exit:
    POP     ACC
    RET

; ========================================================
; DigiTube_Off — 熄灭数码管（等同于 ShowNumber(0)）
; 破坏: 无
; ========================================================
DigiTube_Off:
    PUSH    ACC
    LCALL   DigiTube_Clear
    POP     ACC
    RET

    END
