# Keil uVision project PC_piano.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: PC_piano +hex
  c flags: Optimize=8 SizeSpeed=1
  group App
    ./App/: Main.asm MusicPlayer.asm Protocol.asm Protocol_IR.asm
  group Drv
    ./Drv/: Drv_Gpio.asm Drv_Timer.asm Drv_Uart.asm Drv_IR.asm Drv_DigiTube.asm
  group Bsp
    ./Bsp/: Bsp_Buzzer.asm Bsp_Key.asm Bsp_Led.asm Bsp_DigiTube.asm
  group Lib
    ./Lib/: Delay.asm Math.asm
